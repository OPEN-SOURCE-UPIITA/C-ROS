Commit message: Launch de Simulacion

File: AutoModelCar/simulacion_ws/src/carro_simulacion/urdf/carro.urdf (robot description, URDF)
Before this commit: robot Carros, 10 links, 9 joints
Links:
- link lidar_link: mass None -> 0.1
